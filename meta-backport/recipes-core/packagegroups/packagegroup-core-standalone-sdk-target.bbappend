RDEPENDS_${PN}_append_tegra = " libgcc-8-dev gcc-8-runtime-dev"
PACKAGE_ARCH_tegra = "${TEGRA_PKGARCH}"

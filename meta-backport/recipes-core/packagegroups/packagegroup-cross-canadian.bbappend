RDEPENDS_${PN}_append_tegra = " gcc-8-cross-canadian-${TRANSLATED_TARGET_ARCH}"
